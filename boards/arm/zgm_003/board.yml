## boards/arm/zgm_003/board.yml
```yaml
board:
  name: zgm_003 
  full_name: Nucleo G474RE
  vendor: st
  socs:
    - name: stm32g474xx
```
